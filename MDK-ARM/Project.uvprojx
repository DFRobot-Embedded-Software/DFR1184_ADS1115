# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CS32L010 Chipsea
  pack: Chipsea.CS32L010_DFP.1.0.4
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/CHIPSEA/CS32L010/Include;../Common;../Hardware;../User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/User
    ../User/: cs32l010_hal_msp.c cs32l010_it.c main.c
  group Hardware
    ../Hardware/: ads1115.c DFRobot_I2C_Slave.c uart1.c
software components: CMSIS:CORE 5.4.0, Device:HAL:ADC 1.0.0, Device:HAL:AWK 1.0.0, Device:HAL:BASTIM 1.0.0, Device:HAL:BEEP 1.0.0, Device:HAL:CLKTRIM 1.0.0, Device:HAL:CORTEX 1.0.0, Device:HAL:CRC 1.0.0, Device:HAL:FLASH 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.0, Device:HAL:IWDG 1.0.0, Device:HAL:LPTIM 1.0.0, Device:HAL:LPUART 1.0.0, Device:HAL:LVD 1.0.0, Device:HAL:OWIRE 1.0.0, Device:HAL:PCA 1.0.0, Device:HAL:PWR 1.0.0, Device:HAL:RCC 1.0.0, Device:HAL:RTC 1.0.0, Device:HAL:SPI 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:UART 1.0.0, Device:HAL:VC 1.0.0, Device:HAL:WWDG 1.0.0, Device:Startup 1.0.0
